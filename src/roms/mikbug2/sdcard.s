; Instore direct-register SD transport, fixed ROM API for FLEX and boot loaders.
; A=track, B=sector, X=256-byte buffer for READ/WRITE. READY preserves X.
; Return B=0/Z=1/C=0, or B!=0/Z=0/C=1. Not reentrant.
; The AVR owns $E080/$E081. Each host access must wait for its sequence ACK:
; RX_SEQUENCE toggles after a command/data write, TX_SEQUENCE after a data read.
; Scratch $9B00..$9B11 is reserved above FLEX's $7FFF application limit.
; Scale the timeout loop for a 1..4 MHz host; hardware timing needs validation.
    .equ SD_CPU_MHZ, 1
    .equ SDPORT_COMMAND, 0xE080
    .equ SDPORT_STATUS, 0xE080
    .equ SDPORT_DATA, 0xE081
    .equ SD_RX_SPACE, 0x01
    .equ SD_TX_VALID, 0x02
    .equ SD_RX_SEQUENCE, 0x20
    .equ SD_TX_SEQUENCE, 0x40
    .org 0xF000
sd_read_vector: jmp SDREAD
sd_write_vector: jmp SDWRITE
sd_ready_vector: jmp SDREADY
sd_init_vector: jmp SDRESET
sd_signature: .byte 0x53,0x44,3
; No PIA setup is needed. An initial status read may be stale during AVR reset;
; the next INFO/STATUS exchange in READY checks that the link actually works.
SDRESET: JSR SDWAITRX
 BCC SDRESETOK
 RTS
SDRESETOK: JMP SDOK
SDOK: CLRB
 CLC
 RTS
SDERROR: LDAB #0x10
 SEC
 RTS
SDREAD: CLR SDWRITING
 BRA SDIO
SDWRITE: PSHA
 LDAA #1
 STAA SDWRITING
 PULA
 BRA SDIO
SDIO: STAA SDTRACK
 STAB SDSECTOR
 STX SDBUFFER
 CMPA #128
 BCS SDTRACKOK
 JMP SDERROR
SDTRACKOK: CMPB #1
 BCS SDBADADDR
 CMPB #32
 BLS SDADDRESSOK
SDBADADDR: JMP SDERROR
SDADDRESSOK: JSR SDCHECK
 BCC SDSTARTIO
 RTS
SDSTARTIO: CLR SDSUM
 CLR SDSUM+1
 CLR SDCOUNT
 LDAA #0x10
 ADDA SDWRITING
 JSR SDCOMMAND
 BCS SDSTARTRETURN
 LDAA SDTRACK
 JSR SDPUT
 BCS SDSTARTRETURN
 LDAA SDSECTOR
 JSR SDPUT
 BCC SDSTARTOK
SDSTARTRETURN: RTS
SDSTARTOK: TST SDWRITING
 BNE SDWRITELOOP
 JSR SDGET
 BCS SDRETURN
 TSTA
 BNE SDFAIL
SDREADLOOP: JSR SDGET
 BCS SDRETURN
 LDX SDBUFFER
 STAA 0,X
 JSR SDADD
 INX
 STX SDBUFFER
 DEC SDCOUNT
 BNE SDREADLOOP
 JSR SDGET
 BCS SDRETURN
 STAA SDREMOTE
 JSR SDGET
 BCS SDRETURN
 CMPA SDSUM+1
 BNE SDCHECKFAIL
 LDAA SDREMOTE
 CMPA SDSUM
 BNE SDCHECKFAIL
 JMP SDOK
SDWRITELOOP: LDX SDBUFFER
 LDAA 0,X
 JSR SDADD
 JSR SDPUT
 BCS SDRETURN
 INX
 STX SDBUFFER
 DEC SDCOUNT
 BNE SDWRITELOOP
 LDAA SDSUM
 JSR SDPUT
 BCS SDRETURN
 LDAA SDSUM+1
 JSR SDPUT
 BCS SDRETURN
 JSR SDGET
 BCS SDRETURN
 TSTA
 BNE SDFAIL
 JMP SDOK
SDCHECKFAIL: LDAB #0x08
 SEC
 RTS
SDFAIL: LDAB #0x10
 SEC
SDRETURN: RTS
; Preserve payload A while accumulating unsigned bytes into a 16-bit sum.
SDADD: PSHA
 ADDA SDSUM+1
 STAA SDSUM+1
 BCC SDADDDONE
 INC SDSUM
SDADDDONE: PULA
 RTS
; READY checks INFO version/geometry and mounted-media status.
SDREADY: STX SDREADYX
 JSR SDCHECK
 LDX SDREADYX
 TSTB
 BEQ SDREADYOK
 SEC
 RTS
SDREADYOK: CLC
 RTS
SDCHECK: LDAA #0
 JSR SDCOMMAND
 BCS SDCHECKRETURN
 CLR SDINDEX
SDINFOLOOP: JSR SDGET
 BCS SDCHECKRETURN
 LDX #SDINFO
 LDAB SDINDEX
SDINFOINDEX: TSTB
 BEQ SDINFOCOMPARE
 INX
 DECB
 BRA SDINFOINDEX
SDINFOCOMPARE: CMPA 0,X
 BNE SDINFOMISMATCH
 INC SDINDEX
 LDAB SDINDEX
 CMPB #6
 BNE SDINFOLOOP
 LDAA #1
 JSR SDCOMMAND
 BCS SDCHECKRETURN
 JSR SDGET
 BCS SDCHECKRETURN
 TSTA
 BNE SDFAIL
 JMP SDOK
; Consume the remaining INFO bytes even when the geometry is wrong.
SDINFOMISMATCH: INC SDINDEX
SDINFODRAIN: LDAB SDINDEX
 CMPB #6
 BEQ SDFAIL
 JSR SDGET
 BCS SDCHECKRETURN
 INC SDINDEX
 BRA SDINFODRAIN
SDCHECKRETURN: RTS
; A command is written to $E080; parameters/payload go to $E081.
SDCOMMAND: STAA SDVALUE
 JSR SDWAITRX
 BCS SDPACKETRETURN
 LDAA SDVALUE
 STAA SDPORT_COMMAND
 JSR SDWAITRXACK
 BCS SDPACKETRETURN
 LDAA SDVALUE
 CLC
SDPACKETRETURN: RTS
SDPUT: STAA SDVALUE
 JSR SDWAITRX
 BCS SDPUTRETURN
 LDAA SDVALUE
 STAA SDPORT_DATA
 JSR SDWAITRXACK
 BCS SDPUTRETURN
 LDAA SDVALUE
 CLC
SDPUTRETURN: RTS
; Read one response byte, then wait until the AVR acknowledges consumption.
SDGET: JSR SDWAITTX
 BCS SDGETRETURN
 LDAA SDPORT_DATA
 STAA SDVALUE
 JSR SDWAITTXACK
 BCS SDGETRETURN
 LDAA SDVALUE
 CLC
SDGETRETURN: RTS
; Wait for a write slot and remember its current RX_SEQUENCE value.
SDWAITRX: LDAA #SD_RX_SPACE
 STAA SDWAITMASK
 STAA SDWAITVALUE
 JSR SDWAIT
 BCS SDWAITRETURN
 LDAA SDPORT_STATUS
 ANDA #SD_RX_SEQUENCE
 STAA SDPREVSEQ
 CLC
SDWAITRETURN: RTS
SDWAITRXACK: LDAA #SD_RX_SEQUENCE
 STAA SDWAITMASK
 LDAA SDPREVSEQ
 EORA #SD_RX_SEQUENCE
 STAA SDWAITVALUE
 JMP SDWAIT
; Wait for a response byte and remember its current TX_SEQUENCE value.
SDWAITTX: LDAA #SD_TX_VALID
 STAA SDWAITMASK
 STAA SDWAITVALUE
 JSR SDWAIT
 BCS SDWAITRETURN
 LDAA SDPORT_STATUS
 ANDA #SD_TX_SEQUENCE
 STAA SDPREVSEQ
 CLC
 RTS
SDWAITTXACK: LDAA #SD_TX_SEQUENCE
 STAA SDWAITMASK
 LDAA SDPREVSEQ
 EORA #SD_TX_SEQUENCE
 STAA SDWAITVALUE
 JMP SDWAIT
; Bounded status poll. Preserve caller X and B on success.
SDWAIT: STX SDWAITX
 PSHB
 LDAB #4*SD_CPU_MHZ
SDWAITOUTER: LDX #0
SDWAITLOOP: LDAA SDPORT_STATUS
 ANDA SDWAITMASK
 CMPA SDWAITVALUE
 BEQ SDWAITOK
 DEX
 BNE SDWAITLOOP
 DECB
 BNE SDWAITOUTER
 PULB
 LDX SDWAITX
 JMP SDERROR
SDWAITOK: PULB
 LDX SDWAITX
 CLC
 RTS
SDINFO: .byte 0,3,128,32,0,1
    .equ SDWRITING, 0x9B00
    .equ SDTRACK, 0x9B01
    .equ SDSECTOR, 0x9B02
    .equ SDCOUNT, 0x9B03
    .equ SDINDEX, 0x9B04
    .equ SDREMOTE, 0x9B05
    .equ SDSUM, 0x9B06
    .equ SDBUFFER, 0x9B08
    .equ SDREADYX, 0x9B0A
    .equ SDWAITX, 0x9B0C
    .equ SDVALUE, 0x9B0E
    .equ SDWAITMASK, 0x9B0F
    .equ SDWAITVALUE, 0x9B10
    .equ SDPREVSEQ, 0x9B11
SDROMEND:
