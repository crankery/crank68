; MIKBUG SD bridge ABI v2. The full startup FCB ends at $A97F.
; These adapters fit in the remaining $A980..$A9FF gap before FMEME.
SDREAD PSHA
 PSHB
 JSR SDENSURE
 PULB
 PULA
 BCS SDADAPTERRETURN
 JMP $F000
SDWRITE PSHA
 PSHB
 JSR SDENSURE
 PULB
 PULA
 BCS SDADAPTERRETURN
 JMP $F003
SDREADY JSR SDENSURE
 BCS SDADAPTERRETURN
 JMP $F006
SDADAPTERRETURN RTS
; Old ROMs must report the configured SD drive unavailable.
SDENSURE LDAA $F00C
 CMPA #$53
 BNE SDNOROM
 LDAA $F00D
 CMPA #$44
 BNE SDNOROM
 LDAA $F00E
 CMPA #2
 BNE SDNOROM
 TST SDHOSTINIT
 BNE SDHOSTOK
 JSR $F009
 BCS SDADAPTERRETURN
 INC SDHOSTINIT
SDHOSTOK CLC
 RTS
SDNOROM JMP C68ERROR
SDHOSTINIT FCB 0
SDADAPTEREND FCB 0
