; BIOS contract: copy track 0 sector 1 (image bytes 0..255) to $0100,
; initialize the first ACIA for polling, then JMP $0100. No ROM calls.
; LINK-compatible starting track and sector at offsets 5 and 6.
 org $0100
 bra BOOT
 fcb 0,0,0
LINKT fcb 0
LINKS fcb 0
BOOT SEI
 LDS #$9FFF
 CLR REMAIN
NEXTREC JSR GETBYTE
 CMPA #2
 BEQ ADDRESS
 CMPA #$16
 BEQ TRANSFER
 BRA NEXTREC
ADDRESS JSR GETBYTE
 STAA DEST
 JSR GETBYTE
 STAA DEST+1
 JSR GETBYTE
 STAA COUNT
 BEQ NEXTREC
COPY JSR GETBYTE
 LDX DEST
 STAA 0,X
 INX
 STX DEST
 DEC COUNT
 BNE COPY
 BRA NEXTREC
TRANSFER JSR GETBYTE
 STAA DEST
 JSR GETBYTE
 STAA DEST+1
 LDX DEST
 JMP 0,X
GETBYTE TST REMAIN
 BNE HAVESECTOR
 LDAA LINKS
 BEQ BOOTERROR
 CMPA #16
 BHI BOOTERROR
 DECA
 ADDA #$C0
 STAA PTR
 CLR PTR+1
 LDAA LINKT
 STAA $E002
 LDX PTR
 LDAA 0,X
 STAA LINKT
 LDAA 1,X
 STAA LINKS
 INX
 INX
 INX
 INX
 STX PTR
 LDAA #252
 STAA REMAIN
HAVESECTOR LDX PTR
 LDAA 0,X
 INX
 STX PTR
 DEC REMAIN
 RTS
BOOTERROR BRA BOOTERROR
PTR fdb 0
DEST fdb 0
COUNT fcb 0
REMAIN fcb 0
 end
